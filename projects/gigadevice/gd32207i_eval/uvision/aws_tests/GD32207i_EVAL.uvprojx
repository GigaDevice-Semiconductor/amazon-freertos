# Keil uVision project GD32207i_EVAL.uvprojx, settings and files
target aws_tests (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F207IK GigaDevice
  pack: GigaDevice.GD32F20x_DFP.2.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GD32207i_EVAL
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F207,__little_endian__=1,NDEBUG,AMAZON_FREERTOS_ENABLE_UNIT_TESTS,UNITY_INCLUDE_CONFIG_H
  c include: ..\..\..\..\..\vendors\gigadevice\boards\gd32207i_eval\aws_tests\config_files;..\..\..\..\..\vendors\gigadevice\boards\gd32207i_eval\aws_tests\application_code\gd_code;..\..\..\..\..\vendors\gigadevice\GD32F20x_Firmware_Library\GD32F20x_standard_peripheral\Include;..\..\..\..\..\tests\include;..\..\..\..\..\freertos_kernel\include;..\..\..\..\..\freertos_kernel\portable\RVDS\ARM_CM3;..\..\..\..\..\libraries\freertos_plus\standard\freertos_plus_tcp\include;..\..\..\..\..\libraries\freertos_plus\standard\freertos_plus_tcp\source\portable\Compiler\Keil;..\..\..\..\..\libraries\c_sdk\standard\common\include;..\..\..\..\..\libraries\c_sdk\standard\common\include\private;..\..\..\..\..\libraries\c_sdk\standard\common\include\types;..\..\..\..\..\libraries\c_sdk\standard\mqtt\include;..\..\..\..\..\libraries\c_sdk\standard\mqtt\include\types;..\..\..\..\..\libraries\c_sdk\standard\mqtt\src\private;..\..\..\..\..\libraries\c_sdk\standard\serializer\include;..\..\..\..\..\libraries\c_sdk\standard\https\src\private;..\..\..\..\..\libraries\c_sdk\standard\https\include;..\..\..\..\..\libraries\c_sdk\standard\https\include\types;..\..\..\..\..\libraries\c_sdk\aws\shadow\include;..\..\..\..\..\libraries\c_sdk\aws\shadow\include\types;..\..\..\..\..\libraries\c_sdk\aws\shadow\src\private;..\..\..\..\..\libraries\c_sdk\aws\shadow\src;..\..\..\..\..\libraries\c_sdk\aws\defender\include;..\..\..\..\..\libraries\c_sdk\aws\defender\src\private;..\..\..\..\..\libraries\abstractions\platform\freertos\include;..\..\..\..\..\libraries\abstractions\platform\include;..\..\..\..\..\libraries\abstractions\secure_sockets\include;..\..\..\..\..\libraries\abstractions\pkcs11\include;..\..\..\..\..\libraries\abstractions\pkcs11\mbedtls;..\..\..\..\..\libraries\freertos_plus\standard\tls\include;..\..\..\..\..\libraries\freertos_plus\standard\crypto\include;..\..\..\..\..\libraries\freertos_plus\standard\pkcs11\include;..\..\..\..\..\libraries\freertos_plus\standard\utils\include;..\..\..\..\..\libraries\freertos_plus\aws\greengrass\include;..\..\..\..\..\libraries\3rdparty\mbedtls\include;..\..\..\..\..\libraries\3rdparty\pkcs11;..\..\..\..\..\libraries\3rdparty\tinycbor;..\..\..\..\..\libraries\3rdparty\http_parser;..\..\..\..\..\libraries\3rdparty\jsmn;..\..\..\..\..\demos\dev_mode_key_provisioning\include;..\..\..\..\..\libraries\3rdparty\unity\src;..\..\..\..\..\libraries\3rdparty\unity\extras\fixture\src;..\..\..\..\..\libraries\c_sdk\standard\mqtt\src;..\..\..\..\..\libraries\c_sdk\standard\mqtt\test\access;..\..\..\..\..\libraries\c_sdk\standard\https\test\access;..\..\..\..\..\libraries\c_sdk\standard\https\src;..\..\..\..\..\libraries\freertos_plus\aws\greengrass\src;..\..\..\..\..\libraries\freertos_plus\aws\greengrass\test;..\..\..\..\..\libraries\freertos_plus\standard\freertos_plus_tcp\test
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Application
    ../../../../../vendors/gigadevice/boards/gd32207i_eval/aws_tests/application_code/: main.c
    ../../../../../vendors/gigadevice/boards/gd32207i_eval/aws_tests/application_code/gd_code/: entropy_hardware_poll.c gd32f20x_enet_eval.c gd32f20x_it.c gd32f207i_eval.c
  group vendors/gigadevice/boards/gd207i_eval/ports/pkcs11
    ../../../../../vendors/gigadevice/boards/gd32207i_eval/ports/pkcs11/: iot_pkcs11_pal.c
  group vendors/gigadevice/boards/gd207i_eval/aws_tests/config_files
    ../../../../../vendors/gigadevice/boards/gd32207i_eval/aws_tests/config_files/: aws_bufferpool_config.h aws_demo_config.h aws_ggd_config.h aws_iot_network_config.h aws_mqtt_config.h aws_secure_sockets_config.h aws_shadow_config.h aws_test_pkcs11_config.h aws_test_runner_config.h aws_test_tcp_config.h aws_test_wifi_config.h aws_wifi_config.h FreeRTOSConfig.h FreeRTOSIPConfig.h iot_config.h iot_mqtt_agent_config.h iot_pkcs11_config.h iot_test_pkcs11_config.h unity_config.h
  group GD32F20x_Peripherals
    ../../../../../vendors/gigadevice/GD32F20x_Firmware_Library/GD32F20x_standard_peripheral/Source/: gd32f20x_adc.c gd32f20x_bkp.c gd32f20x_can.c gd32f20x_cau.c gd32f20x_cau_aes.c gd32f20x_cau_des.c gd32f20x_cau_tdes.c gd32f20x_crc.c gd32f20x_dac.c gd32f20x_dbg.c gd32f20x_dci.c gd32f20x_dma.c gd32f20x_enet.c gd32f20x_exmc.c gd32f20x_exti.c gd32f20x_fmc.c gd32f20x_fwdgt.c gd32f20x_gpio.c gd32f20x_hau.c gd32f20x_hau_sha_md5.c gd32f20x_i2c.c gd32f20x_misc.c gd32f20x_pmu.c gd32f20x_rcu.c gd32f20x_rtc.c gd32f20x_sdio.c gd32f20x_spi.c gd32f20x_timer.c gd32f20x_tli.c gd32f20x_trng.c gd32f20x_usart.c gd32f20x_wwdgt.c
  group FreeRTOS
    ../../../../../freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../freertos_kernel/portable/MemMang/: heap_4.c
    ../../../../../freertos_kernel/portable/RVDS/ARM_CM3/: port.c
  group CMSIS
    ../../../../../vendors/gigadevice/GD32F20x_Firmware_Library/CMSIS/GD/GD32F20x/Source/: system_gd32f20x.c
  group Startup
    ../../../../../vendors/gigadevice/GD32F20x_Firmware_Library/CMSIS/GD/GD32F20x/Source/ARM/: startup_gd32f20x_cl.s
  group FreeRTOS_Plus_TCP
    ../../../../../libraries/freertos_plus/standard/freertos_plus_tcp/source/: FreeRTOS_ARP.c FreeRTOS_DHCP.c FreeRTOS_DNS.c FreeRTOS_IP.c FreeRTOS_Sockets.c FreeRTOS_Stream_Buffer.c FreeRTOS_TCP_IP.c FreeRTOS_TCP_WIN.c FreeRTOS_UDP_IP.c
    ../../../../../libraries/freertos_plus/standard/freertos_plus_tcp/source/portable/BufferManagement/: BufferAllocation_2.c
  group FreeRTOS_Plus_TCP_Port
    ../../../../../libraries/freertos_plus/standard/freertos_plus_tcp/source/portable/NetworkInterface/Gigadevice/GD32F20x/: NetworkInterface.c
  group libraries/c_sdk/standard/common
    ../../../../../libraries/c_sdk/standard/common/: iot_device_metrics.c iot_init.c iot_static_memory_common.c
  group libraries/c_sdk/standard/common/logging
    ../../../../../libraries/c_sdk/standard/common/logging/: iot_logging.c iot_logging_task_dynamic_buffers.c
  group libraries/c_sdk/standard/common/taskpool
    ../../../../../libraries/c_sdk/standard/common/taskpool/: iot_taskpool.c iot_taskpool_static_memory.c
  group libraries/c_sdk/standard/mqtt/src
    ../../../../../libraries/c_sdk/standard/mqtt/src/: iot_mqtt_agent.c iot_mqtt_api.c iot_mqtt_network.c iot_mqtt_operation.c iot_mqtt_serialize.c iot_mqtt_static_memory.c iot_mqtt_subscription.c iot_mqtt_validate.c
  group libraries/c_sdk/standard/serializer/src
    ../../../../../libraries/c_sdk/standard/serializer/src/: iot_json_utils.c iot_serializer_static_memory.c
  group libraries/c_sdk/standard/serializer/src/cbor
    ../../../../../libraries/c_sdk/standard/serializer/src/cbor/: iot_serializer_tinycbor_decoder.c iot_serializer_tinycbor_encoder.c
  group libraries/c_sdk/standard/serializer/src/json
    ../../../../../libraries/c_sdk/standard/serializer/src/json/: iot_serializer_json_decoder.c iot_serializer_json_encoder.c
  group libraries/c_sdk/standard/https/src
    ../../../../../libraries/c_sdk/standard/https/src/: iot_https_client.c iot_https_utils.c
  group libraries/c_sdk/aws/shadow/src
    ../../../../../libraries/c_sdk/aws/shadow/src/: aws_iot_shadow_api.c aws_iot_shadow_operation.c aws_iot_shadow_parser.c aws_iot_shadow_static_memory.c aws_iot_shadow_subscription.c aws_shadow.c
  group libraries/c_sdk/aws/defender/src
    ../../../../../libraries/c_sdk/aws/defender/src/: aws_iot_defender_api.c aws_iot_defender_collector.c aws_iot_defender_mqtt.c aws_iot_defender_v1.c
  group libraries/abstractions/platform/freertos
    ../../../../../libraries/abstractions/platform/freertos/: iot_clock_freertos.c iot_metrics.c iot_network_freertos.c iot_threads_freertos.c
  group libraries/abstractions/secure_sockets/freertos_plus_tcp
    ../../../../../libraries/abstractions/secure_sockets/freertos_plus_tcp/: iot_secure_sockets.c
  group libraries/abstractions/pkcs11/mbedtls
    ../../../../../libraries/abstractions/pkcs11/mbedtls/: iot_pkcs11_mbedtls.c
  group libraries/freertos_plus/standard/tls/src
    ../../../../../libraries/freertos_plus/standard/tls/src/: iot_tls.c
  group libraries/freertos_plus/standard/crypto/src
    ../../../../../libraries/freertos_plus/standard/crypto/src/: iot_crypto.c
  group libraries/freertos_plus/standard/pkcs11/src
    ../../../../../libraries/freertos_plus/standard/pkcs11/src/: iot_pkcs11.c
  group libraries/freertos_plus/standard/utils/src
    ../../../../../libraries/freertos_plus/standard/utils/src/: iot_pki_utils.c iot_system_init.c
  group libraries/freertos_plus/aws/greengrass/src
    ../../../../../libraries/freertos_plus/aws/greengrass/src/: aws_greengrass_discovery.c aws_helper_secure_connect.c
  group libraries/3rdparty/mbedtls/library
    ../../../../../libraries/3rdparty/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group libraries/3rdparty/mbedtls/utils
    ../../../../../libraries/3rdparty/mbedtls/utils/: mbedtls_utils.c
  group libraries/3rdparty/tinycbor
    ../../../../../libraries/3rdparty/tinycbor/: cborpretty.c cborencoder.c cborencoder_close_container_checked.c cborerrorstrings.c cborparser.c cborparser_dup_string.c
  group libraries/3rdparty/http_parser
    ../../../../../libraries/3rdparty/http_parser/: http_parser.c
  group libraries/3rdparty/jsmn
    ../../../../../libraries/3rdparty/jsmn/: jsmn.c
  group demos/dev_mode_key_provisioning/src
    ../../../../../demos/dev_mode_key_provisioning/src/: aws_dev_mode_key_provisioning.c
  group tests/common
    ../../../../../tests/common/: aws_test.c aws_test_framework.c aws_test_runner.c iot_test_freertos.c iot_tests_network.c
  group tests/include
    ../../../../../tests/include/: aws_application_version.h aws_clientcredential.h aws_clientcredential_keys.h aws_test_framework.h aws_test_runner.h aws_test_tcp.h aws_test_utils.h aws_unity_config.h iot_config_common.h
  group libraries/3rdparty/unity/src
    ../../../../../libraries/3rdparty/unity/src/: unity.c
  group libraries/3rdparty/unity/extras/fixture/src
    ../../../../../libraries/3rdparty/unity/extras/fixture/src/: unity_fixture.c
  group libraries/c_sdk/aws/defender/test
    ../../../../../libraries/c_sdk/aws/defender/test/: aws_iot_tests_defender_api.c
  group libraries/c_sdk/aws/shadow/test
    ../../../../../libraries/c_sdk/aws/shadow/test/: aws_test_shadow.c
    ../../../../../libraries/c_sdk/aws/shadow/test/unit/: aws_iot_tests_shadow_api.c aws_iot_tests_shadow_parser.c
    ../../../../../libraries/c_sdk/aws/shadow/test/system/: aws_iot_tests_shadow_system.c
  group libraries/c_sdk/standard/common/test
    ../../../../../libraries/c_sdk/standard/common/test/: iot_memory_leak.c iot_tests_taskpool.c
  group libraries/c_sdk/standard/https/test
    ../../../../../libraries/c_sdk/standard/https/test/unit/: iot_tests_https_async.c iot_tests_https_client.c iot_tests_https_common.c iot_tests_https_sync.c iot_tests_https_utils.c
    ../../../../../libraries/c_sdk/standard/https/test/system/: iot_tests_https_system.c
  group libraries/c_sdk/standard/mqtt/test
    ../../../../../libraries/c_sdk/standard/mqtt/test/: iot_test_mqtt_agent.c
    ../../../../../libraries/c_sdk/standard/mqtt/test/unit/: iot_tests_mqtt_api.c iot_tests_mqtt_metrics.c iot_tests_mqtt_receive.c iot_tests_mqtt_subscription.c iot_tests_mqtt_validate.c
    ../../../../../libraries/c_sdk/standard/mqtt/test/system/: iot_tests_mqtt_system.c
  group libraries/c_sdk/standard/serializer/test
    ../../../../../libraries/c_sdk/standard/serializer/test/: iot_tests_deserializer_json.c iot_tests_serializer_cbor.c iot_tests_serializer_json.c
  group libraries/freertos_plus/aws/greengrass/test
    ../../../../../libraries/freertos_plus/aws/greengrass/test/: aws_test_greengrass_discovery.c aws_test_helper_secure_connect.c
  group libraries/freertos_plus/standard/crypto/test
    ../../../../../libraries/freertos_plus/standard/crypto/test/: iot_test_crypto.c
  group libraries/freertos_plus/standard/tls/test
    ../../../../../libraries/freertos_plus/standard/tls/test/: iot_test_tls.c
  group libraries/abstractions/pkcs11/test
    ../../../../../libraries/abstractions/pkcs11/test/: iot_test_pkcs11.c
  group libraries/abstractions/platform/test
    ../../../../../libraries/abstractions/platform/test/: iot_test_platform_clock.c iot_test_platform_threads.c
  group libraries/abstractions/secure_sockets/test
    ../../../../../libraries/abstractions/secure_sockets/test/: iot_test_tcp.c
software components: CMSIS:CORE 5.1.2
